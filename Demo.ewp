# IAR project Demo.ewp, settings and files
configuration Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X
  ICCARM.CCIncludePath2: stm32\CMSIS\Device\ST\STM32F30x\Include\; stm32\STM32F30x_StdPeriph_Driver\inc\; USER_CODE\; uCos-II\Source\; uCos-II\Ports\; uCos-II\Config\; uCos-II\uC-LIB\; uCos-II\uC-CPU\; stm32\; BaseLib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: uCos-II\Source\; uCos-II\Ports\; uCos-II\Config\; uCos-II\uC-LIB\; uCos-II\uC-CPU\
  OBJCOPY.OOCOutputFile: STM32F3_Discovery_Demo_V1.1.0.hex
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkIcfFile: stm32f30x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    stm32/CMSIS/Device/ST/STM32F30x/Source/Templates/iar/: startup_stm32f30x.s
  group BaseLib
    BaseLib/: BaseLib.h BaseLib_Exti.c BaseLib_Exti.h BaseLib_Pwm.c BaseLib_Pwm.h BaseLib_TimerInterrupt.c BaseLib_TimerInterrupt.h BaseLib_Types.c BaseLib_Types.h BaseLib_Usart.c BaseLib_Usart.h
  group STM32F3-Discovery
    stm32/: bsp.c bsp.h bsp_int.c
    USER_CODE/: stm32f3_discovery.c stm32f3_discovery_l3gd20.c stm32f3_discovery_lsm303dlhc.c
  group STM32F30x_StdPeriph_Driver
    stm32/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group uCos-II/Config
    uCOS-II/Config/: app_cfg.h cpu_cfg.h os_cfg.h
  group uCos-II/Ports
    uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCos-II/Source
    uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uCos-II/uC-CPU
    uCOS-II/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group uCos-II/uC-LIB
    uCOS-II/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group User
    USER_CODE/: main.c stm32f30x_it.c system_stm32f30x.c
